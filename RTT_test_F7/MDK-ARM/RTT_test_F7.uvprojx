# Keil uVision project RTT_test_F7.uvprojx, settings and files
target RTT_test_F7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: RTT_test_F7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RT-Thread//include/;../Middlewares/Third_Party/RT-Thread//components/drivers/include/;../Middlewares/Third_Party/RT-Thread//components/drivers/include/drivers/;../Middlewares/Third_Party/RT-Thread//components/drivers/include/ipc/;../Middlewares/Third_Party/RT-Thread//bsp/
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: main.c app_rtthread.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/RT-Thread/RTOS/device drivers
    ../Middlewares/Third_Party/RT-Thread/components/drivers/serial/: serial.c
    ../Middlewares/Third_Party/RT-Thread/components/drivers/src/: completion.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RT-Thread/libcpu/arm/cortex-m7/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RT-Thread/bsp/: board.c
    ../Middlewares/Third_Party/RT-Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
software components: CMSIS:CORE 4.3.0
